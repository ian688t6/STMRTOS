# Keil uVision project rtos.uvprojx, settings and files
target Rtos (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtos +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\core;.\system;.\stm32_fwlib\inc;.\os\include;.\os\portable\RVDS\ARM_CM3;.\bsp;.\bsp\board;.\bsp\share
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group core
    ./core/: core_cm3.c startup_stm32f10x_hd.s
  group stm32lib
    ./stm32_fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group system
    ./system/: stm32f10x_it.c system_stm32f10x.c rtos_sys.c rtos_delay.c rtos_console.c
  group app
    ./app/: main.c
  group os
    ./os/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group portable
    ./os/portable/MemMang/: heap_4.c
    ./os/portable/RVDS/ARM_CM3/: port.c
  group bsp
    ./bsp/: bsp_uart.c bsp_disp.c
  group board
    ./bsp/board/: board.c lcd_tft9341.c
